# IAR project Clock1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC1310F128 TexasInstruments CC1310F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.IExtraOptions: -f; configPkg/compiler.opt.defs; --diag_suppress=Pa050; -I$CC13XXWARE$; -Dewarm; --debug; --silent
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: Clock1.out
  ILINK.IlinkIcfFile: $PROJ_FNAME$_CC1310DK_7XD.icf
  ILINK.IlinkExtraOptions: -f; configPkg/linker.cmd; $CC13XXWARE$/driverlib/bin/iar/driverlib.lib; --silent; --cpu=Cortex-M3; --entry=__iar_program_start; --redirect; _Printf=_PrintfSmall; --redirect; _Scanf=_ScanfSmall
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Clock Example/Configuration files
    ./: Clock1.cfg
  group Clock Example/Documentation
    ./: README.html
  group Clock Example/Header files
    ./: Board.h CC1310DK_7XD.h
  group Clock Example/Source files
    ./: CC1310DK_7XD.c ccfg.c clock.c Clock1_CC1310DK_7XD.icf
